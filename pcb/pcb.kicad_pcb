File: pcb/pcb.kicad_pcb (KiCad board)
At the start: 2 copper layers, 1 part

Commit message: chore
Parts:
- moved U1 50.5 mm to (64.8, 78.3)
